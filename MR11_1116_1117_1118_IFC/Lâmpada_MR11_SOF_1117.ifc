Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-03-03T12:37:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 03 12:37:08 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\a853f39d-256d-423e-a41f-684bc1fadc68\81bf0951-6a99-4822-afa1-17550a9e0de5\ifc * Database version: 5507 * Database creation date: Mon Mar 03 12:37:06 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 03 12:37:08 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 03 12:37:08 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328327
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 1117 - 3000K, Lâmpada_MR11_SOF_1116_1117_1118_Nordecor_IFC:1117 - 3000K:328327
In: Nível 1
Type - Material: Metal - Ferro, Plástico - Branco - Fosco, Plástico - Acrilico - Translucido, LED
Type - Cotas - Altura: 48 mm; Diâmetro: 35 mm
Type - Dados - Data de atualização: 24/02/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Lâmpada de LED MR11 SOF 3.5W 3000K 36º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Camboriú-SC / Brasil; Modelo: 1116; Nome do tipo: 1117 - 3000K; Número OmniClass: 23.80.70.00; Observação: Soquete GU 10; Tipo de imagem: Imagem raster: MR11.jpg; Título OmniClass: Lighting; URL: https://nordecor.com.br/; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/lampada-mini-dicroica-mr11-sof-35w-2-700k-3-000k-4-000k/; Vida útil: 25.000h
Type - Elétrico - Comentários de voltagem: 100-240VAC; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Lâmpada: 0 W
Type - Engenharia elétrica - Corrente elétrica: 0.04 A; Fator de potência - Lâmpada: 0.4; Frequência: 0 Hz; Voltagem - Lâmpada: 0 V
Type - Estrutural - Peso: 0.022Kg
Type - Fotométricos - Ângulo de abertura: 36 deg; Fluxo luminoso: 210 lm; Potência: 3.5 W; Temperatura de cor: 3000 K
Type - Gráficos - Simbologia: Imagem raster: 1117.png
Type - Materiais e acabamentos - MR11: Alumínio e polímero sintético
Type - Outros - Categoria: Luminárias; 2700K - 36º: no; 3000K - 36º: yes; 4000K - 36º: no; Branco: yes; Nome da família: Lâmpada_MR11_SOF_1116_1117_1118_Nordecor_IFC
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Cotas - Área: 0.00389593 m2; Volume: 0.0000260242 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Lâmpada_MR11_SOF_1116_1117_1118_Nordecor_IFC: 1117 - 3000K; Família e tipo: Lâmpada_MR11_SOF_1116_1117_1118_Nordecor_IFC: 1117 - 3000K; ID de tipo: Lâmpada_MR11_SOF_1116_1117_1118_Nordecor_IFC: 1117 - 3000K; Tipo: Lâmpada_MR11_SOF_1116_1117_1118_Nordecor_IFC: 1117 - 3000K
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
